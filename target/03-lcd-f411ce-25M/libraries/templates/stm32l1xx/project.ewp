# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CB ST STM32L151CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L151xB; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\libcpu\arm\cortex-m3; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; board\ports; ..\..\..\components\drivers\include; ..\libraries\STM32L1xx_HAL\STM32L1xx_HAL_Driver\Inc; .; applications; ..\libraries\HAL_Drivers\config; board; ..\libraries\STM32L1xx_HAL\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\components\libc\compilers\common; ..\libraries\STM32L1xx_HAL\CMSIS\Include; board\CubeMX_Config\Inc; ..\..\..\include; ..\libraries\HAL_Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32L1xx_hal_msp.c
    ../libraries/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32L151xb.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../libraries/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32L1xx.c
    ../libraries/STM32L1xx_HAL/STM32L1xx_HAL_Driver/Src/: stm32L1xx_hal_dma.c stm32L1xx_hal_cortex.c stm32L1xx_hal_crc.c stm32L1xx_hal_pwr.c stm32L1xx_hal_rcc.c stm32L1xx_hal_rcc_ex.c stm32L1xx_hal.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32L1xx_hal_sram.c stm32L1xx_hal_gpio.c stm32L1xx_hal_uart.c stm32L1xx_hal_usart.c
